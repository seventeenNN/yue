# Keil uVision project BH-F429.uvprojx, settings and files
target EXTI (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EXTI
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\User\led;..\..\User\key;..\..\User\dma;..\..\User\iwdg;..\..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_qy_gpio.c stm32f4xx_qy_rcc.c stm32f4xx_qy_dma.c
  group USER
    ../../User/: main.c stm32f4xx_it.c stm32f4xx_it.h
    ../../User/led/: bsp_led.c
    ../../User/key/: bsp_key.c
    ../../User/dma/: bsp_dma.c
    ../../User/exti/: bsp_exti.c
    ../../User/iwdg/: bsp_iwdg.c
    ../../User/usart/: bsp_usart.c
  group DOC
    ../../: 必读说明.txt
